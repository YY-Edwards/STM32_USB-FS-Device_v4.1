# IAR project VirtualComport_Loopback.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\RTOS\Template; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\src; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\inc; ..\src; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\mylib; ..\mylib\SMBus\IIC; ..\mylib\SYS; ..\mylib\SMBus; ..\mylib\SMBus\LTC4015; ..\mylib\LOG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkOutputFile: VirtualComport_Loopback.out
  ILINK.IlinkIcfFile: VirtualComport_Loopback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\RTOS\Template; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\src; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\inc; ..\src; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL; ..\mylib
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM3210B-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_XL_VirtualComport_Loopback.bin
configuration STM32L152-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_VirtualComport_Loopback.bin
configuration STM32L152D-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32L152D-EVAL_VirtualComport_Loopback.bin
configuration STM32373C_EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
configuration STM32303C_EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
configuration STM32303xE_EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
configuration STM32F302x8_Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: STM32F302x8_Nucleo_VirtualComport_Loopback.bin
  group Doc
    ../: readme.txt
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM3210B_EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM32F10x/STM3210E_EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F30X/CMSIS
    ./: startup_stm32f302x8.s startup_stm32f303xc.s startup_stm32f303xe.s
    ../src/: system_stm32f30x.c
  group STM32F30X/STM32303C_EVAL
    ../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group STM32F30X/STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_usart.c
  group STM32F37X/CMSIS
    ./: startup_stm32f37x.s
    ../src/: system_stm32f37x.c
  group STM32F37X/STM32373C_EVAL
    ../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c
  group STM32F37X/STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_usart.c
  group STM32L1xx/CMSIS
    ./: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
    ../src/: system_stm32l1xx.c
  group STM32L1xx/STM32L152_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: hw_config.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group User/mylib
    ../mylib/: delay.c
  group User/mylib/LOG
    ../mylib/LOG/: logger.c logger.h
    ../mylib/: myqueue.c myqueue.h
  group User/mylib/SMBus
    ../mylib/SMBus/: SMBus.c SMBus.h Typedefs.h
  group User/mylib/SMBus/IIC
    ../mylib/SMBus/IIC/: myiic.c myiic.h
  group User/mylib/SMBus/LTC4015
    ../mylib/SMBus/LTC4015/: LTC4015.c LTC4015.h LTC4015_formats.h LTC4015_reg_defs.h
  group User/mylib/SYS
    ../mylib/SYS/: sys.c sys.h
